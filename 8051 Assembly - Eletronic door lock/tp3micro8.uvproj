# Keil uVision project tp3micro8.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F388 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: tp3micro8 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: tp3micro8.a51
